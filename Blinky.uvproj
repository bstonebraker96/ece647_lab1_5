# Keil uVision project Blinky.uvproj, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: HSE_VALUE=8000000 VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Flash OPT
    ./: STM32F40xxx_41xxx_OPT.s
  group Source Files
    ./: LED.c Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32F407 Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
